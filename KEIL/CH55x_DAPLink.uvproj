# Keil uVision project CH55x_DAPLink.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: CH55x_DAPLink +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../SRC/: DAP.c Debug.C Main_Usb.C SW_DP.c SW_DP_asm.a51 Uart.c Timer.C Timer.H
